# Keil uVision project Watchdog.uvproj, settings and files
target Simulator (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2105 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Watchdog
  c flags: Optim=1 oTime=1
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Startup Code
    ./: Startup.s
  group System Calls
    ./: Retarget.c WT.c WT.h
  group Source Code
    ./: main.c RTC.c RTC.h Serial_port.c Serial_port.h
  group Documentation
    ./: Abstract.txt
