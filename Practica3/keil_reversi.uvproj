# Keil uVision project keil_reversi.uvproj, settings and files
target Simulator (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2105 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: keil_reversi
  c flags: Optim=1 uC99=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Startup Code
    ./: Startup.s
  group System Calls
    ./: Retarget.c
  group Source Code
    ./: Power_management.h boton_eint0.c boton_eint0.h GPIO.c Eventos.c cola.c boton_eint1.c reversi8.c boton_eint1.h Power_management.c main.c timer0.c timer0.h timer1.h timer1.c patron_volteo_arm_arm.s Eventos.h reversi8.h WT.c cola.h GPIO.h SWI.h WT.h SWI.s RTC.c RTC.h UART0.c comandos.c comandos.h UART0.h
    ./test/: test_uart0.c
